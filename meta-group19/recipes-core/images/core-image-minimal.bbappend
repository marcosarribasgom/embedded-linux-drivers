IMAGE_INSTALL += "hello-module"

